# Keil uVision project tcs.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: tcs +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\src;.\Lib\inc;.\Startup;.\Basic\delay;.\Hardware\oled;.\User;.\Hardware\DHT22;.\Hardware\key;.\Hardware\SCP;.\Basic\exti;.\Basic\tim;.\Basic\iwdg
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/exti/: exti.c
    ./Basic/tim/: tim.c
    ./Basic/iwdg/: iwdg.c
  group Hardware
    ./Hardware/oled/: OLED_I2C.c
    ./Hardware/DHT22/: DHT22.c
    ./Hardware/key/: KEY.c
    ./Hardware/SCP/: SCP.c
  group User
    ./User/: main.c stm32f10x_it.c display.c
